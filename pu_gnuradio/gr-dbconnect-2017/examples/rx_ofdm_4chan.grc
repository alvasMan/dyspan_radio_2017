<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx_ofdm</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>OFDM RX Phy</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_factor</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_carriers</value></param>
<param><key>value</key><value>(range(-26, -21) + range(-20, -7) + range(-6, 0) + range(1, 7) + range(8, 21) + range(22, 27),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_carriers</value></param>
<param><key>value</key><value>((-21, -7, 7, 21,),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_symbols</value></param>
<param><key>value</key><value>((1, 1, 1, -1,),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word1</value></param>
<param><key>value</key><value>[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word2</value></param>
<param><key>value</key><value>[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>rx_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>rx_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>rx_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>rx_len</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>dbconnect_pktrecv</key>
<param><key>id</key><value>dbconnect_pktrecv_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>port</key><value>5002</value></param>
<param><key>server</key><value>127.0.0.1</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_0</value></param>
<param><key>cp_len</key><value>fft_len/4</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>packet_len_key</key><value>"rx_len"</value></param>
<param><key>payload_mod</key><value>"QPSK"</value></param>
<param><key>pilot_carriers</key><value>pilot_carriers</value></param>
<param><key>pilot_symbols</key><value>pilot_symbols</value></param>
<param><key>sync_word1</key><value>sync_word1</value></param>
<param><key>sync_word2</key><value>sync_word2</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_0_0</value></param>
<param><key>cp_len</key><value>fft_len/4</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>packet_len_key</key><value>"rx_len"</value></param>
<param><key>payload_mod</key><value>"QPSK"</value></param>
<param><key>pilot_carriers</key><value>pilot_carriers</value></param>
<param><key>pilot_symbols</key><value>pilot_symbols</value></param>
<param><key>sync_word1</key><value>sync_word1</value></param>
<param><key>sync_word2</key><value>sync_word2</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_0_1</value></param>
<param><key>cp_len</key><value>fft_len/4</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>packet_len_key</key><value>"rx_len"</value></param>
<param><key>payload_mod</key><value>"QPSK"</value></param>
<param><key>pilot_carriers</key><value>pilot_carriers</value></param>
<param><key>pilot_symbols</key><value>pilot_symbols</value></param>
<param><key>sync_word1</key><value>sync_word1</value></param>
<param><key>sync_word2</key><value>sync_word2</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_0_2</value></param>
<param><key>cp_len</key><value>fft_len/4</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>packet_len_key</key><value>"rx_len"</value></param>
<param><key>payload_mod</key><value>"QPSK"</value></param>
<param><key>pilot_carriers</key><value>pilot_carriers</value></param>
<param><key>pilot_symbols</key><value>pilot_symbols</value></param>
<param><key>sync_word1</key><value>sync_word1</value></param>
<param><key>sync_word2</key><value>sync_word2</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0</value></param>
<param><key>center_freq</key><value>1.25e6</value></param>
<param><key>decim</key><value>decim_factor</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>samp_rate</key><value>usrp_samp_rate</value></param>
<param><key>taps</key><value>filter.firdes.low_pass(1,usrp_samp_rate, samp_rate/2.0*0.98, 5000)</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0_0</value></param>
<param><key>center_freq</key><value>-1.25e6</value></param>
<param><key>decim</key><value>decim_factor</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>samp_rate</key><value>usrp_samp_rate</value></param>
<param><key>taps</key><value>filter.firdes.low_pass(1,usrp_samp_rate, samp_rate/2.0*0.98, 5000)</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0_1</value></param>
<param><key>center_freq</key><value>3.75e6</value></param>
<param><key>decim</key><value>decim_factor</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>samp_rate</key><value>usrp_samp_rate</value></param>
<param><key>taps</key><value>filter.firdes.low_pass(1,usrp_samp_rate, samp_rate/2.0*0.98, 5000)</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0_2</value></param>
<param><key>center_freq</key><value>-3.75e6</value></param>
<param><key>decim</key><value>decim_factor</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>samp_rate</key><value>usrp_samp_rate</value></param>
<param><key>taps</key><value>filter.firdes.low_pass(1,usrp_samp_rate, samp_rate/2.0*0.98, 5000)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>from gnuradio import filter</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>usrp_samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Scope Plot</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_1</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>1255e6</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>5</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.20.2</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>usrp_samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>dbconnect_pktrecv_0</sink_block_id><source_key>pdus</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>dbconnect_pktrecv_0</sink_block_id><source_key>pdus</source_key><sink_key>in1</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_1</source_block_id><sink_block_id>dbconnect_pktrecv_0</sink_block_id><source_key>pdus</source_key><sink_key>in2</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_2</source_block_id><sink_block_id>dbconnect_pktrecv_0</sink_block_id><source_key>pdus</source_key><sink_key>in3</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0_1</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0_2</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0</source_block_id><sink_block_id>digital_ofdm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0_0</source_block_id><sink_block_id>digital_ofdm_rx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0_1</source_block_id><sink_block_id>digital_ofdm_rx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0_2</source_block_id><sink_block_id>digital_ofdm_rx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
